Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: acd121e5-4210-4dec-af72-148ab6eee3c5, NumberOfSaves: 1]
File name: 0001
Time: 2025-07-11T07:53:19+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12798750_NWE_PLW8683_SST:62868316_NWE_12798750_PLW8683_SST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Cast, z_Miele_Design_Glass, z_Miele_Design_GRGR, <Unnamed>, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Network
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 62868316_NWE_12798750_PLW8683_SST; sets with these values: 2
